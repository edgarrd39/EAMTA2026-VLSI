v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {blocks/inverter/schematic/inverter.sym} -100 0 0 0 {name=x1}
