v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {blocks/nandgate/schematic/nand.sym} -30 -40 0 0 {name=x1}
C {blocks/inverter/schematic/inverter.sym} 150 -20 0 0 {name=x2}
